## west.yml
```yaml
manifest:
  projects:
    - name: zmk
      url: https://github.com/innovaker/zmk
      revision: modular-v2
      import: true
```
